# Keil uVision project GUI.uvprojx, settings and files
target GUI (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: GUI
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\HARDWARE\LCD; ..\emWin522\Config; ..\emWin522\inc; ..\emWin522\Lib; ..\emWin522\OS; ..\HARDWARE\RC522; ..\HARDWARE\TOUCH; ..\HARDWARE\sys; ..\HARDWARE\OV7725; ../Middlewares/Third_Party/FatFs/src/drivers; ../Middlewares/Third_Party/FatFs/src; ../Inc; ..\HARDWARE\TOUCH; ..\HARDWARE\W25X16; ..\Demo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_sram.c stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_cortex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_spi.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c
  group Application/User
    ../HARDWARE/LCD/: ILI93xx.c
    ../HARDWARE/OV7725/: ov7725.c sccb.c
    ../HARDWARE/bmp/: bsp_bmp.c
    ../HARDWARE/RC522/: manager.c motor.c rc522_app.c rc522_config.c rc522_function.c
    ../HARDWARE/TOUCH/: touch.c
    ../HARDWARE/W25X16/: spi_flash.c
    ../Src/: crc.c rtc.c stm32f4xx_it.c main.c fatfs.c spi.c stm32f4xx_hal_msp.c sdio.c usart.c tim.c bsp_driver_sd.c gpio.c fsmc.c
  group emWin
    ../emWin522/Config/: GUIConf.c LCDConf_FlexColor_Template.c GUI_X_Touch_Analog.c
    ../emWin522/OS/: GUI_X.c
    ../emWin522/Lib/: STemWin522_CM3_Keil.lib
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.1.0
